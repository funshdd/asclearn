# Keil uVision project Kaohe2_Lock.uvproj, settings and files
target KAOHE2_A_D8_OFF (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: Kaohe2_Lock_A +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: D8_ALWAYS_ON=0
  group User
    ../User/: main.c board.c timer.c uart.c nixie.c key.c iap.c lock.c config.h board.h timer.h uart.h nixie.h key.h iap.h lock.h
target KAOHE2_B_D8_ON (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: Kaohe2_Lock_B +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: D8_ALWAYS_ON=1
