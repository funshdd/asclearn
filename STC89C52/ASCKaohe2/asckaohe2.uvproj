# Keil uVision project asckaohe2.uvproj, settings and files
target A_D8_OFF (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: asckaohe2_A +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: D8_ALWAYS_ON=0
  group Source Group 1
    ./: main.c Nixie.h Nixie.c Uart.h Uart.c Delay.h Delay.c IIC.h IIC.c EEPROM.h EEPROM.c Tick.h Tick.c Key.h Key.c Event.h Event.c Password.h Password.c States.h States.c UartStringAsm.h UartStringAsm.c Feedback.h Feedback.c
target B_D8_ON (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: asckaohe2_B +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: D8_ALWAYS_ON=1
